%TITLE%
  FBL 010510/0100     

   LEVEL       HGHT       TEMP       DWPT       WDIR       WSPD
-------------------------------------------------------------------
%RAW%
  967.88,    317.63,     24.35,     14.11,    161.80,     12.68
  950.00,    480.79,     23.38,     12.91,    169.48,     21.76
  925.00,    713.54,     22.93,     12.53,    186.35,     33.44
  900.00,    951.29,     21.15,     11.13,    193.75,     36.50
  875.00,   1194.29,     19.23,      9.61,    202.12,     37.72
  850.00,   1443.04,     17.35,      8.07,    211.81,     39.08
  825.00,   1697.30,     15.40,      6.59,    218.06,     40.32
  800.00,   1957.30,     13.33,      5.37,    226.60,     43.53
  775.00,   2222.55,     11.13,      3.52,    233.61,     44.91
  750.00,   2495.30,      9.03,      0.42,    237.53,     44.36
  725.00,   2775.30,      6.85,     -2.86,    242.87,     43.02
  700.00,   3062.30,      4.55,     -4.81,    246.95,     41.67
  675.00,   3357.81,      2.15,     -7.00,    250.79,     41.29
  650.00,   3661.30,     -0.30,     -9.30,    254.82,     40.91
  625.00,   3973.57,     -2.82,    -11.67,    258.80,     40.66
  600.00,   4295.07,     -5.50,    -13.71,    262.18,     40.87
  575.00,   4627.57,     -8.17,    -15.04,    263.27,     42.38
  550.00,   4970.82,    -10.97,    -16.55,    263.73,     44.39
  525.00,   5325.82,    -13.85,    -18.38,    264.12,     46.15
  500.00,   5694.82,    -16.60,    -21.16,    265.05,     46.31
  475.00,   6077.58,    -19.42,    -24.16,    265.96,     45.80
  450.00,   6477.58,    -22.60,    -27.07,    266.91,     44.82
  425.00,   6893.58,    -25.95,    -30.12,    268.33,     43.44
  400.00,   7329.58,    -29.47,    -33.26,    268.62,     42.89
  375.00,   7786.09,    -33.22,    -36.71,    268.09,     42.66
  350.00,   8267.08,    -37.20,    -40.49,    267.80,     43.06
  325.00,   8774.09,    -41.40,    -44.63,    267.22,     43.81
  300.00,   9311.83,    -45.98,    -49.31,    267.70,     45.25
  275.00,   9884.59,    -50.88,    -54.48,    269.37,     47.39
  250.00,  10497.34,    -56.05,    -59.86,    271.94,     50.01
  225.00,  11158.83,    -61.55,    -65.48,    276.04,     53.44
  200.00,  11878.59,    -65.17,    -69.29,    281.48,     51.26
  175.00,  12705.58,    -57.55,    -64.44,    280.87,     39.95
  150.00,  13691.05,    -54.46,    -64.30,    282.85,     33.03
  125.00,  14862.30,    -55.15,    -66.07,    263.73,     23.19
  100.00,  16315.76,    -56.35,    -65.54,    257.43,     17.36
   75.00,  18189.61,    -54.46,    -64.30,    282.85,     33.03
   50.00,  20830.64,    -54.46,    -64.30,    282.85,     33.03
%END%

----- Parcel Information-----
*** 50mb MIXED LAYER PARCEL ***
LPL:  P=968  T=78F  Td=55F
CAPE:              1919 J/kg
CINH:              -209 J/kg
LI:                  -6 C
LI(300mb):           -7 C
3km Cape:             7 J/kg
NCAPE:             0.21 m/s2

LCL:	   796mb       1680m
LFC:       700mb       2745m
EL:        195mb      11718m
MPL:       144mb      13636m
All heights AGL

----- Moisture -----
Precip Water:	 1.04 in
Mean W:          9.5 g/Kg

----- Lapse Rates -----
700-500mb   21 C 	8.2 C/km
850-500mb   35 C	8.3 C/km

----- Note -----
Old Title:  RUC 010510/0100F000    fbl 

